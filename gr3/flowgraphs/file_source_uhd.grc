options:
  parameters:
    author: Daniel Estevez
    generate_options: qt_gui
    id: file_source_gui
    output_language: python
    title: File Source + QT GUI
  states: {}

blocks:
- name: gain
  id: variable_qtgui_entry
  parameters:
    label: Digital gain
    type: real
    value: '0.25'
  states: {}
- name: rf_freq
  id: variable_qtgui_entry
  parameters:
    label: RF Frequency
    type: real
    value: 1260e6
  states: {}
- name: rf_gain
  id: variable_qtgui_entry
  parameters:
    label: RF Gain
    type: real
    value: '60'
  states: {}
- name: samp_rate
  id: variable
  parameters:
    value: 1000e3
  states: {}
- name: blocks_file_source_0
  id: blocks_file_source
  parameters:
    file: ../../build/test_fifo
    repeat: 'False'
    type: complex
  states: {}
- name: blocks_multiply_const_vxx_0
  id: blocks_multiply_const_vxx
  parameters:
    const: gain
    type: complex
  states: {}
- name: qtgui_freq_sink_x_0
  id: qtgui_freq_sink_x
  parameters:
    bw: samp_rate
    fc: '0'
    fftsize: '4096'
    type: complex
  states: {}
- name: qtgui_time_sink_x_0
  id: qtgui_time_sink_x
  parameters:
    size: '1024'
    srate: samp_rate
    type: complex
  states: {}
- name: uhd_usrp_sink_0
  id: uhd_usrp_sink
  parameters:
    ant0: '"TX/RX"'
    center_freq0: uhd.tune_request(rf_freq, samp_rate * 4)
    gain0: rf_gain
    samp_rate: samp_rate
    sync: sync
    type: fc32
  states: {}

connections:
- [blocks_file_source_0, '0', blocks_multiply_const_vxx_0, '0']
- [blocks_file_source_0, '0', qtgui_freq_sink_x_0, '0']
- [blocks_file_source_0, '0', qtgui_time_sink_x_0, '0']
- [blocks_multiply_const_vxx_0, '0', uhd_usrp_sink_0, '0']

metadata:
  file_format: 1
  grc_version: 3.10.10.0
